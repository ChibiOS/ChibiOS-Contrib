# Keil uVision project ch.uvprojx, settings and files
target Demo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: ch +hex
  c flags: Optim=3 uC99=1 wLevel=2
  c define: CORTEX_USE_FPU=0  TEST_CFG_SIZE_REPORT=0 __heap_base__=Image$$$$RW_IRAM1$$$$ZI$$$$Limit __heap_end__=Image$$$$RW_IRAM1$$$$Base
  c misc: -UWB32FQ95xx
  c include: ..\;..\cfg;..\..\..\..\..\ChibiOS\os\license;..\..\..\..\..\ChibiOS-Contrib\os\common\startup\ARMCMx\devices\WB32FQ95xx;..\..\..\..\..\ChibiOS\os\common\ext\ARM\CMSIS\Core\Include;..\..\..\..\..\ChibiOS-Contrib\os\common\ext\CMSIS\WB32\WB32FQ95xx;..\..\..\..\..\ChibiOS\os\common\portability\Keil;..\..\..\..\..\ChibiOS\os\common\ports\ARM-common;..\..\..\..\..\ChibiOS\os\common\ports\ARMv7-M;..\..\..\..\..\ChibiOS\os\rt\include;..\..\..\..\..\ChibiOS\os\oslib\include;..\..\..\..\..\ChibiOS\os\hal\osal\rt-nil;..\..\..\..\..\ChibiOS\os\hal\include;..\board;..\..\..\..\..\ChibiOS\os\hal\ports\common\ARMCMx;..\..\..\..\..\ChibiOS-Contrib\os\hal\ports\WB32\WB32FQ95xx;..\..\..\..\..\ChibiOS-Contrib\os\hal\ports\WB32\LLD\GPIOv1;..\..\..\..\os\hal\ports\WB32\LLD\DMAv1;..\..\..\..\os\hal\ports\WB32\LLD\TIMv1;..\..\..\..\..\ChibiOS\os\test\include;..\..\..\..\..\ChibiOS\test\rt\source\test;..\..\..\..\..\ChibiOS\test\oslib\source\test;..\..\..\..\os\hal\ports\WB32\LLD\RTCv1;..\..\..\..\os\hal\ports\WB32\LLD\UARTv1;..\..\..\..\..\ChibiOS\os\hal\templates;..\..\..\..\os\hal\include;..\..\..\..\os\hal\ports\WB32\LLD\EXTIv1
  asm misc: --cpreproc --cpreproc_opts=-DCORTEX_USE_FPU=0
  asm include: ..\;..\cfg;..\..\..\..\..\ChibiOS\os\license;..\..\..\..\..\ChibiOS-Contrib\os\common\startup\ARMCMx\devices\WB32FQ95xx;..\..\..\..\..\ChibiOS\os\common\ports\ARMv7-M;..\board
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x9000
  memory RVCT10: RAM 0x2000a000 size 0x1
  group license
    ../../../../../ChibiOS/os/license/: chcustomer.h chlicense.h chversion.h
  group startup
    ../../../../../ChibiOS/os/common/startup/ARMCMx/compilers/RVCT/: cstartup.s vectors.s
    ../../../../../ChibiOS-Contrib/os/common/startup/ARMCMx/devices/WB32FQ95xx/: cmparams.h
  group cmsis
    ../../../../../ChibiOS/os/common/ext/ARM/CMSIS/Core/Include/: core_cm3.h
    ../../../../../ChibiOS-Contrib/os/common/ext/CMSIS/WB32/WB32FQ95xx/: wb32fq95xx.h
  group kernel port
    ../../../../../ChibiOS/os/common/ports/ARMv7-M/: chcore.c chcore.h mpu.h
    ../../../../../ChibiOS/os/common/ports/ARMv7-M/compilers/RVCT/: chcoreasm.s
  group kernel
    ../../../../../ChibiOS/os/rt/include/: chalign.h ch.h chcond.h chdebug.h chdynamic.h chevents.h chmsg.h chmtx.h chregistry.h chschd.h chsem.h chstats.h chsys.h chthreads.h chtm.h chvt.h chchecks.h chtrace.h chrestrictions.h chtime.h
    ../../../../../ChibiOS/os/rt/src/: chcond.c chdebug.c chdynamic.c chevents.c chmsg.c chmtx.c chregistry.c chschd.c chsem.c chstats.c chsys.c chthreads.c chtm.c chvt.c chrfcu.c chinstances.c chtrace.c
  group oslib
    ../../../../../ChibiOS/os/oslib/include/: chbsem.h chdelegates.h chfactory.h chjobs.h chlib.h chmboxes.h chmemcore.h chmemheaps.h chmempools.h chobjcaches.h chobjfifos.h chpipes.h
    ../../../../../ChibiOS/os/oslib/src/: chdelegates.c chfactory.c chmboxes.c chmemcore.c chmemheaps.c chmempools.c chobjcaches.c chpipes.c chmemchecks.c
  group osal
    ../../../../../ChibiOS/os/hal/osal/rt-nil/: osal.c osal.h
  group hal
    ../../../../../ChibiOS/os/hal/include/: hal.h hal_adc.h hal_buffers.h hal_can.h hal_channels.h hal_dac.h hal_files.h hal_gpt.h hal_i2c.h hal_i2s.h hal_icu.h hal_ioblock.h hal_mac.h hal_mii.h hal_mmc_spi.h hal_mmcsd.h hal_pal.h hal_pwm.h hal_queues.h hal_rtc.h hal_sdc.h hal_serial.h hal_serial_usb.h hal_spi.h hal_st.h hal_streams.h hal_uart.h hal_usb.h hal_usb_cdc.h hal_wdg.h hal_crypto.h hal_efl.h hal_flash.h hal_objects.h hal_persistent.h hal_sio.h hal_trng.h hal_wspi.h
    ../../../../../ChibiOS/os/hal/src/: hal.c hal_adc.c hal_buffers.c hal_can.c hal_dac.c hal_gpt.c hal_i2c.c hal_i2s.c hal_icu.c hal_mac.c hal_mmc_spi.c hal_mmcsd.c hal_pal.c hal_pwm.c hal_queues.c hal_rtc.c hal_sdc.c hal_serial.c hal_serial_usb.c hal_spi.c hal_st.c hal_uart.c hal_usb.c hal_wdg.c hal_crypto.c hal_efl.c hal_flash.c hal_sio.c hal_trng.c hal_wspi.c
  group hal_port
    ../../../../../ChibiOS-Contrib/os/hal/ports/WB32/LLD/GPIOv1/: hal_pal_lld.c
    ../../../../../ChibiOS-Contrib/os/hal/ports/WB32/WB32FQ95xx/: hal_lld.c wb32_isr.c
    ../../../../../ChibiOS/os/hal/ports/common/ARMCMx/: nvic.c
    ../../../../os/hal/ports/WB32/LLD/TIMv1/: hal_st_lld.c
    ../../../../os/hal/ports/WB32/LLD/RTCv1/: hal_rtc_lld.c
    ../../../../os/hal/ports/WB32/LLD/UARTv1/: hal_serial_lld.c
    ../../../../os/hal/ports/WB32/LLD/EXTIv1/: wb32_exti.c
  group board
    ../board/: board.c board.h
  group test
    ../../../../../ChibiOS/test/rt/source/test/: rt_test_root.c rt_test_sequence_001.c rt_test_sequence_002.c rt_test_sequence_003.c rt_test_sequence_004.c rt_test_sequence_005.c rt_test_sequence_006.c rt_test_sequence_007.c rt_test_sequence_008.c rt_test_sequence_009.c rt_test_sequence_010.c rt_test_sequence_011.c rt_test_sequence_012.c
    ../../../../../ChibiOS/test/oslib/source/test/: oslib_test_root.c oslib_test_sequence_001.c oslib_test_sequence_002.c oslib_test_sequence_003.c oslib_test_sequence_004.c oslib_test_sequence_005.c oslib_test_sequence_006.c oslib_test_sequence_007.c oslib_test_sequence_008.c oslib_test_sequence_009.c
    ../../../../../ChibiOS/os/test/src/: ch_test.c ch_test_printf.c
  group demo
    ../: main.c debug.c
    ../cfg/: chconf.h halconf.h mcuconf.h
    ../../../../../ChibiOS/os/common/lib/src/: chprintf.c memstreams.c
    ../../../../../ChibiOS/os/common/oop/src/: oop_base_object.c
